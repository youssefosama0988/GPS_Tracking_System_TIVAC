# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./GPS_Tracking_System-/Source/MCAL/: eeprom.c GPIO.c SysTick.c UART.c
    ./GPS_Tracking_System-/Source/HAL/: GPS_module.c LCD.c LED.c GPS_mohamed.c
    ./GPS_Tracking_System-/Source/APP/: APP.c
    ./GPS_Tracking_System-/Headers/Services/: Bit-utilies.h startup_TM4C123.s TM4C123.h types.h
    ./GPS_Tracking_System-/Headers/MCAL/: eeprom.h GPIO.h SysTick.h UART.h
    ./GPS_Tracking_System-/Headers/HAL/: GPS_module.h LCD.h LED.h GPS_mohamed.h
